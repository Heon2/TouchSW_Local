# Keil uVision project APP_ForLGD.uvprojx, settings and files
target MFTP FPGA (ARM-ADS)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.0.1
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: MFTP +hex
  AfterMake: fromelf.exe --bin "bin\MFTP.axf" -o "bin\binary\APP.bin"
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: _USE_APP_80K_
  c misc: --c99 --wchar32
  c include: ..\..\App_LIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x20000
  scatter file: .\APP_ForLGD.scat
  group App
    ../../App_LIB/: app_lib.c startup.s algorithm.lib pwm_lib_param.c sric_lib_param.c
