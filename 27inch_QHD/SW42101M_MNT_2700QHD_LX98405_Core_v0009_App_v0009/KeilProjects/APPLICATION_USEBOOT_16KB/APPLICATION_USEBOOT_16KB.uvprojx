# Keil uVision project APPLICATION_USEBOOT_16KB.uvprojx, settings and files
target MFTP FPGA (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.0.1
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: MFTP +hex
  AfterMake: app_Build_post_process.bat
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: _USE_APP_80K_, USE_BOOTLOADER_16KB
  c misc: --c99 --wchar32
  c include: ..\..\App;..\..\App\Algorithm;..\..\App\Algorithm\Baseline;..\..\App\Algorithm\Coord;..\..\App\Algorithm\Label;..\..\App\Algorithm\Noise;..\..\Env;..\..\Hal;..\..\Hal\system;..\..\Hal\system\CMSIS;..\..\Hal\gpio;..\..\Hal\i2c;..\..\Hal\pwmdrv;..\..\Hal\timer;..\..\Hal\wdgt;..\..\Hal\spi;..\..\Hal\dspA;..\..\Hal\dspB;..\..\Hal\scrb;..\..\Hal\usb;..\..\Hal\usb\FWOTG210_F000;..\..\Hal\usb\FWOTG210_F000\OTG_peripheral;..\..\Hal\usb\FWOTG210_F000\OTG_peripheral_Config;..\..\Module;..\..\Module\SRIC;..\..\Protocol;..\..\Hal\dma;..\..\Tool_BinCvt\BinToolApp\src;..\..\Boot;..\..\Parameter;..\..\Hal\misc;..\..\Hal\flitf;..\..\Env\env_model_L;..\..\Env\env_model_L\customer\DEFAULT;..\..\Env
  memory RVCT4: ROM 0x2000 size 0x1e000
  memory RVCT10: RAM 0x20000000 size 0x20000
  scatter file: .\MFTP_SiW_USEBOOT_16KB.scat
  group App
    ../../App/: app.c app_conf.c app_dfup.c app_diag.c app_main.c app_normal.c app_info.c
    ../../Test/: app_test_func.c app_test_main.c app_test_sirc.c app_test_pwm.c
  group App_Algorithm
    ../../App/Algorithm/: algorithm.c algorithm_conf.c
    ../../App/Algorithm/Baseline/: algorithm_baseline.c
    ../../App/Algorithm/Coord/: algorithm_coord.c
    ../../App/Algorithm/Label/: algorithm_label.c
    ../../App/Algorithm/Noise/: algorithm_noise.c
  group Hal
    ../../Hal/: hal.c hal_conf.c hal_fnc.c interrupt.c memory_pool.c
  group Hal_system
    ../../Hal/system/: startup.s
  group Hal_peri
    ../../Hal/gpio/: gpio.c
    ../../Hal/i2c/: i2c.c
    ../../Hal/pwmdrv/: pwmdrv.c
    ../../Hal/spi/: mspi.c
    ../../Hal/timer/: systick.c timer.c
    ../../Hal/wdgt/: wdgt.c
    ../../Hal/dspA/: dspA.c
    ../../Hal/dspB/: DSP_B.c DSP_B_code.c
    ../../Hal/scrb/: scrb.c
    ../../Hal/misc/: misc.c
    ../../Hal/flitf/: flitf.c
  group Hal_usb
    ../../Hal/usb/FWOTG210_F000/: Pe_my_usbtable.c Pe_usb.c
  group Module
    ../../Module/: module.c module_conf.c
    ../../Module/SRIC/lx98405/: roic_ctrl_lx98405.c
  group Module_SRIC
    ../../Module/SRIC/: sric.c
  group Protocol
    ../../Protocol/: protocol.c protocol_conf.c protocol_dfup.c protocol_log.c protocol_swip.c
  group Tool
    ../../Tool_BinCvt/BinToolApp/src/: crc.c
  group Parameter
    ../../Parameter/: param.c param_config_fixed.c param_config_preset.c
