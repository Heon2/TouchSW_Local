# Keil uVision project APP_SIMPLE_BOOT.uvprojx, settings and files
target MFTP FPGA (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.0.0
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: MFTP +hex
  AfterMake: app_Build_post_process.bat
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: _USE_APP_80K_ _USE_WITH_BOOT_
  c misc: --c99 --wchar32
  c include: ..\..\App;..\..\App\Algorithm;..\..\App\Algorithm\Baseline;..\..\App\Algorithm\Coord;..\..\App\Algorithm\Label;..\..\App\Algorithm\Noise;..\..\Env;..\..\Hal;..\..\Hal\system;..\..\Hal\system\CMSIS;..\..\Hal\gpio;..\..\Hal\i2c;..\..\Hal\pwmdrv;..\..\Hal\timer;..\..\Hal\wdgt;..\..\Hal\spi;..\..\Hal\dspA;..\..\Hal\dspB;..\..\Hal\scrb;..\..\Hal\usb;..\..\Hal\usb\FWOTG210_F000;..\..\Hal\usb\FWOTG210_F000\OTG_peripheral;..\..\Hal\usb\FWOTG210_F000\OTG_peripheral_Config;..\..\Hal\gdma;..\..\Hal\syscfg;..\..\Hal\flitf;..\..\Module;..\..\Module\SRIC;..\..\Protocol;..\..\Tool_BinCvt\BinToolApp\src;..\..\Boot;..\..\Parameter;..\..\Hal\dbgserial;..\..\Hal\tlvds;..\..\Tuning_process
  memory RVCT4: ROM 0x2000 size 0x1e000
  memory RVCT10: RAM 0x20000000 size 0x20000
  scatter file: .\MFTP_SiW_APP_SIMPLE_BOOT.scat
  group App_Simple_Boot
    ../../App_Simple_Boot/: app_simple_boot.c app_simple_hal.c
  group Hal_system
    ../../Hal/system/: startup.s
