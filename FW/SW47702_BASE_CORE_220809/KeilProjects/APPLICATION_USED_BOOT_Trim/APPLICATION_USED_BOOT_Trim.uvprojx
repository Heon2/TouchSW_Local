# Keil uVision project APPLICATION_USED_BOOT_Trim.uvprojx, settings and files
target MFTP FPGA (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.0.0
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: MFTP +hex
  AfterMake: app_Build_post_process.bat
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: _USE_APP_80K_ _USE_WITH_BOOT_
  c misc: --c99 --wchar32
  c include: ..\..\App;..\..\App\Algorithm;..\..\App\Algorithm\Baseline;..\..\App\Algorithm\Coord;..\..\App\Algorithm\Label;..\..\App\Algorithm\Noise;..\..\Env;..\..\Hal;..\..\Hal\system;..\..\Hal\system\CMSIS;..\..\Hal\gpio;..\..\Hal\i2c;..\..\Hal\pwmdrv;..\..\Hal\timer;..\..\Hal\wdgt;..\..\Hal\spi;..\..\Hal\dspA;..\..\Hal\dspB;..\..\Hal\scrb;..\..\Hal\usb;..\..\Hal\usb\FWOTG210_F000;..\..\Hal\usb\FWOTG210_F000\OTG_peripheral;..\..\Hal\usb\FWOTG210_F000\OTG_peripheral_Config;..\..\Hal\gdma;..\..\Hal\syscfg;..\..\Hal\flitf;..\..\Module;..\..\Module\SRIC;..\..\Protocol;..\..\Tool_BinCvt\BinToolApp\src;..\..\Boot;..\..\Parameter;..\..\Hal\dbgserial;..\..\Hal\tlvds;..\..\Tuning_process
  memory RVCT4: ROM 0x2000 size 0x1e000
  memory RVCT10: RAM 0x20000000 size 0x20000
  scatter file: .\MFTP_SiW_APP.scat
  group App
    ../../App/: app.c app_conf.c app_dfup.c app_diag.c app_main.c app_normal.c app_info.c
    ../../Tuning_process/: app_tuning_process.c
  group App_Algorithm
    ../../App/Algorithm/: algorithm.c algorithm_conf.c
    ../../App/Algorithm/Baseline/: algorithm_baseline.c
    ../../App/Algorithm/Coord/: algorithm_coord.c
    ../../App/Algorithm/Label/: algorithm_label.c
    ../../App/Algorithm/Noise/: algorithm_noise.c
  group Hal
    ../../Hal/: hal.c hal_conf.c hal_fnc.c interrupt.c memory_pool.c memory_pool_local.c
  group Hal_system
    ../../Hal/system/: startup.s
  group Hal_peri
    ../../Hal/gpio/: gpio.c
    ../../Hal/i2c/: i2c.c i2cm.c
    ../../Hal/pwmdrv/: pwmdrv.c
    ../../Hal/spi/: mspi.c
    ../../Hal/wdgt/: wdgt.c
    ../../Hal/dspA/: dspA.c
    ../../Hal/dspB/: DSP_B.c DSP_B_code.c DSP_B_code_2.c
    ../../Hal/timer/: timer.c timer_tick.c
    ../../Hal/scrb/: scrb.c
    ../../Hal/flitf/: flitf.c
  group Hal_usb
    ../../Hal/usb/FWOTG210_F000/: Pe_my_usbtable.c Pe_usb.c
  group Module
    ../../Module/: module.c module_conf.c
  group Module_SRIC
    ../../Module/SRIC/: sric.c
    ../../Module/SRIC/ROIC/SW92502/: roic_ctrl_sw92502.c
    ../../Module/SRIC/ROIC/SW97500/: roic_ctrl_sw97500.c
    ../../Module/SRIC/ROIC/SW92503/: roic_ctrl_sw92503.c
    ../../Module/SRIC/ROIC/SW92503S/: roic_ctrl_sw92503s.c
    ../../Module/SRIC/ROIC/SW98500/: roic_ctrl_sw98500.c
    ../../Module/SRIC/ROIC/SW92503B/: roic_ctrl_sw92503B.c
    ../../Module/SRIC/ROIC/SW92505/: roic_ctrl_sw92505.c
    ../../Module/SRIC/ROIC/SW98502/: roic_ctrl_sw98502.c
    ../../Module/SRIC/ROIC/SW92508/: roic_ctrl_sw92508.c
    ../../Module/SRIC/ROIC/SW92509/: roic_ctrl_sw92509.c
    ../../Module/SRIC/ROIC/SW92510/: roic_ctrl_sw92510.c
    ../../Module/SRIC/ROIC/SW92511/: roic_ctrl_sw92511.c
    ../../Module/SRIC/ROIC/SW92512/: roic_ctrl_sw92512.c
    ../../Module/SRIC/ROIC/SW92513/: roic_ctrl_sw92513.c
  group Protocol
    ../../Protocol/: protocol.c protocol_conf.c protocol_log.c protocol_swip.c
  group Tool
    ../../Tool_BinCvt/BinToolApp/src/: crc.c
  group Parameter
    ../../Parameter/: param.c param_config_fixed.c param_config_preset.c
